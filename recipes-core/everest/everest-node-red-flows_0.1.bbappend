# Build fix for styhead
S = "${WORKDIR}/sources"
UNPACKDIR = "${S}"
