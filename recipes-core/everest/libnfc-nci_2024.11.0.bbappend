INSANE_SKIP += "buildpaths"
