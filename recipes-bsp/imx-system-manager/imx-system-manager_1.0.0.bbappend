FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-Modified-config-for-imx943-EVerest-one-gun.patch \
"