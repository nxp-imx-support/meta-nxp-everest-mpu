SUMMARY = "caio: Asynchronous file IO for Linux MacOS or Windows."

HOMEPAGE = "https://github.com/mosquito/caio"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e"

SRC_URI[sha256sum] = "8f30511526814d961aeef389ea6885273abe6c655f1e08abbadb95d12fdd9b4f"

PYPI_PACKAGE = "caio"

inherit pypi setuptools3
