PYPI_PACKAGE = "poetry_core"
UPSTREAM_CHECK_PYPI_PACKAGE = "${PYPI_PACKAGE}"