# Build fix for styhead
LIC_FILES_CHKSUM = "file://py4j-0.10.9/LICENSE.txt;md5=92361a2681db50d1bc207c47c49c1a8e"

S = "${WORKDIR}/sources"
UNPACKDIR = "${S}"
