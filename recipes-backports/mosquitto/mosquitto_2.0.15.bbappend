do_install:prepend() {
	cp ${WORKDIR}/sources-unpack/mosquitto.init ${WORKDIR}/
}
